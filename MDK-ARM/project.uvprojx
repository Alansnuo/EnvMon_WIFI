# Keil uVision project project.uvprojx, settings and files
target project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../BSP/dht11;../BSP;../BSP/ESP8266;../freertos;../freertos/inc;../freertos/port;../freertos/src;../APP;../BSP/bsp_delay;../BSP/BH1750;../BSP/ASR;../BSP/OLED;../BSP/KEY;../BSP/MyI2C;../BSP/PWM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group APP
    ../APP/: app_config.h app_main.c app_main.h app_ui.c app_ui.h task_wifi.c task_wifi.h task_dht11.c task_dht11.h task_light.c task_light.h task_asr.c task_asr.h task_oled.c task_oled.h task_key.c task_key.h app_delay.c
  group BSP
    ../BSP/dht11/: dht11.c dht11.h
    ../BSP/ESP8266/: esp8266.c esp8266.h
    ../BSP/bsp_delay/: bsp_delay.c bsp_delay.h
    ../BSP/BH1750/: BH1750.c BH1750.h
    ../BSP/MyI2C/: MyI2C.c MyI2C.h
    ../BSP/ASR/: asr.c asr.h
    ../BSP/OLED/: OLED.c OLED.h OLED_Font.h
    ../BSP/KEY/: key.c key.h
    ../BSP/PWM/: pwm.c pwm.h
  group freertos/inc
    ../freertos/inc/: FreeRTOSConfig.h atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group freertos/port
    ../freertos/port/: heap_4.c port.c portmacro.h
  group freertos/src
    ../freertos/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
software components: CMSIS:CORE 4.3.0
